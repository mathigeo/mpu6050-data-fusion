# Keil uVision project project.uvprojx, settings and files
target project (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\CMSIS\startup;.\CMSIS;.\FWlib\inc;.\Src;.\User;.\Public;.\Src\MPU6050;.\Src\MPU6050\I2C;.\Src\MPU6050\mpu6050;.\Src\MPU6050\MPUExti;.\Src\gpio;.\Src\MPU6050\mpu6050\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ./FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group PUBLIC
    ./Public/: system.c usart.c systick.c
  group USER
    ./User/: main.c stm32f10x_it.c
  group SRC
    ./Src/MPU6050/I2C/: i2c.c
    ./Src/MPU6050/mpu6050/: mpu6050.c
    ./Src/MPU6050/MPUExti/: mpuExti.c
    ./Src/gpio/: gpio.c
    ./Src/MPU6050/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./Src/: mpu_cmpl.c
  group DOC
    ./Doc/: readme.txt
